RDEPENDS:${PN}:remove = " \
    qtmultimedia \
    qtspeech \
    qtinterfaceframework \
"

