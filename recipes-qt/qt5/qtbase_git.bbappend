PACKAGECONFIG_append = " accessibility no-opengl"
PACKAGECONFIG_remove = "examples tests"
