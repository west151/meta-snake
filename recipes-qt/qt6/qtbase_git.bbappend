PACKAGECONFIG_append = " accessibility fontconfig sql-sqlite kms gbm"
PACKAGECONFIG_remove = "examples tests"
